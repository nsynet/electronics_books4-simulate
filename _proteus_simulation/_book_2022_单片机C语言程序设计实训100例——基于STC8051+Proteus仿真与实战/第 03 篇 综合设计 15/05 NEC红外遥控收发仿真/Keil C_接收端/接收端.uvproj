# Keil uVision project 接收端.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 接收端 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LCD1602-4bit.c main.c
