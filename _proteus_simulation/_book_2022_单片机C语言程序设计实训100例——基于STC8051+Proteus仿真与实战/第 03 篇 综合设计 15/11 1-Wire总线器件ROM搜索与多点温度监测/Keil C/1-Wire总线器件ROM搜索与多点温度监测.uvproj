# Keil uVision project 1-Wire总线器件ROM搜索与多点温度监测.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 1-Wire总线器件ROM搜索与多点温度监测 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LM044L-4bit.c 1-Wire.c 1-Wire.h LM044L-4bit.h
