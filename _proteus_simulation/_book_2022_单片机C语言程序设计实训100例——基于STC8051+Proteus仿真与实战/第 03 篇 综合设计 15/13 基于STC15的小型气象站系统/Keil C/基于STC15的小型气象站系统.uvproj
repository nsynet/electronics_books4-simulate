# Keil uVision project 基于STC15的小型气象站系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 基于STC15的小型气象站系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Si7021.c LM044L-4bit.c MPL3115A2.c Weather.c
