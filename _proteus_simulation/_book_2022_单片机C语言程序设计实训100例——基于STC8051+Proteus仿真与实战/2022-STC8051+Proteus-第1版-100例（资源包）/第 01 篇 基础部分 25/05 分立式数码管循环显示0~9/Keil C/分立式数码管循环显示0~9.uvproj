# Keil uVision project 分立式数码管循环显示0~9.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 分立式数码管循环显示0~9 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
