# Keil uVision project Nokia5110(PCD8544)液晶演示.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Nokia5110(PCD8544)液晶演示 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Nokia5110.c Nokia5110.h
