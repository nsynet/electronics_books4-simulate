# Keil uVision project I2C接口存储器AT24C04读写与显示(4片).uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: I2C接口存储器AT24C04读写与显示(4片) +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c 24C04.c
