# Keil uVision project I2C接口8位精度4通道A／D与单通道D／A转换器PCF8591应用.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: I2C接口8位精度4通道A／D与单通道D／A转换器PCF8591应用 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c PCF8591.c i2c.h LCD1602-4bit.c LCD1602-4bit.h
