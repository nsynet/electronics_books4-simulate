# Keil uVision project 通过I2C接口控制MAX6955驱动16段数码管显示.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 通过I2C接口控制MAX6955驱动16段数码管显示 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c I2C.h
