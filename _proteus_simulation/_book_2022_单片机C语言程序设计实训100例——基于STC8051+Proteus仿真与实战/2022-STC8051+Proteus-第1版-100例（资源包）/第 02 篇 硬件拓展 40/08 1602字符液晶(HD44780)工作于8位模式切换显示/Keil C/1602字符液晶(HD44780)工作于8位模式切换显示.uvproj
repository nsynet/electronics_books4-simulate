# Keil uVision project 1602字符液晶(HD44780)工作于8位模式切换显示.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 1602字符液晶(HD44780)工作于8位模式切换显示 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD1602.c
