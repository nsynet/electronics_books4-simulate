# Keil uVision project 38 NTC热敏电阻应用测试.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 数码管显示两路AD转换结果 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
