# Keil uVision project SPI接口存储器AT25F1024读写.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 用SPI接口读写AT25F1024 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
