# Keil uVision project 用24C04与1602LCD设计电子密码锁.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(33000000) MODAT2
  output: 用1602LCD+24C04设计的电子密码锁 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c 24C04.C KeyPAD.c i2c.h LCD1602-4bit.c
