# Keil uVision project 可接收串口信息的带中英文硬字库的80x16LED点阵屏.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 可接收串口信息的带中英文硬字库的80x16LED点阵屏 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c AT25F4096.c
