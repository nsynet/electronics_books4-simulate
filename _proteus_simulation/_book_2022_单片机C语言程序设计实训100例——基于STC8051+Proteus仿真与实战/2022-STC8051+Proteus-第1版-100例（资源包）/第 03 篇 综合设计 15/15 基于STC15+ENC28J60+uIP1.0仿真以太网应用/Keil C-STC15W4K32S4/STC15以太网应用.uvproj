# Keil uVision project STC15以太网应用.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: STC15以太网应用 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c uart.c spi.c enc28j60.c uip.c uip_arp.c Delay.c Delay.h My_Macro.h timer.c app_server.c
