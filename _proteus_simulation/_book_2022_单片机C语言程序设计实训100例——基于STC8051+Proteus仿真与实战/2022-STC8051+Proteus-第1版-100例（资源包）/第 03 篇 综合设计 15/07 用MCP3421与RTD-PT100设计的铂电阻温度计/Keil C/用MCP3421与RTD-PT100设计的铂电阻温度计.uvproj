# Keil uVision project 用MCP3421与RTD-PT100设计的铂电阻温度计.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 用MCP3421与RTD-PT100设计的铂电阻温度计 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c I2C_MCP3421.c I2C.h LGM12864_KS0108.c LGM12864_KS0108.h
