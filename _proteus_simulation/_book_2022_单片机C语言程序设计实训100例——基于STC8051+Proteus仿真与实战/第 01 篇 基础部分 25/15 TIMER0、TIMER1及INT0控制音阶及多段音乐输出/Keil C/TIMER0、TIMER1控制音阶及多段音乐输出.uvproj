# Keil uVision project TIMER0、TIMER1控制音阶及多段音乐输出.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: TIMER0、TIMER1控制音阶及多段音乐输出 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
