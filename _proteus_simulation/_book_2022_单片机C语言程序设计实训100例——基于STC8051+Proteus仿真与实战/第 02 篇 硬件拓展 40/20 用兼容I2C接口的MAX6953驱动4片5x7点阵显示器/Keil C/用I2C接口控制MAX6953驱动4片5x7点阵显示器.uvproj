# Keil uVision project 用I2C接口控制MAX6953驱动4片5x7点阵显示器.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 用I2C接口控制MAX6953驱动4片5x7点阵显示器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: I2C.h main.c
