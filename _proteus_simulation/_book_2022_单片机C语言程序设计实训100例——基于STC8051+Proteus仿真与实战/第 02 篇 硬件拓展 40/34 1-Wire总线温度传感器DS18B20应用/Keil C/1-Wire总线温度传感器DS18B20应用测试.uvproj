# Keil uVision project 1-Wire总线温度传感器DS18B20应用测试.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 1-Wire总线温度传感器DS18B20应用测试 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ds18b20.c main.c LCD1602-4bit.c
