# Keil uVision project 1602字符液晶(HD44780)工作于4位模式显示DS1302时钟.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 1602字符液晶(HD44780)工作于4位模式显示DS1302时钟 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c DS1302.c DS1302.h LCD1602-4bit.c
