# Keil uVision project 温湿度传感器SHT75应用.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 温湿度传感器SHT75应用 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: SHT75.C LM041L-4bit.c LM041L-4bit.h
