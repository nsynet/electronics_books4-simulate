# Keil uVision project UG-2864(SSD1306)I2C-OLED显示测试.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: UG-2864(SSD1306)I2C-OLED显示测试 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\SRC
  group Source Group 1
    ./: main.c I2C.h bmp.h oled.c oled.h oledfont.h STC15xxx.h
