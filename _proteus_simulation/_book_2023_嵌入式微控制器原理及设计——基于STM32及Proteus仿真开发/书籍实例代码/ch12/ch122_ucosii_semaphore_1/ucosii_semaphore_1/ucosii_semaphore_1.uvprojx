# Keil uVision project ucosii_semaphore_1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: .\ucosii\config;.\ucosii\core;.\ucosii\port;.\user;.\lib\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ucosii_core
    ./ucosii/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucosii_port
    ./ucosii/port/: os_cpu_c.c os_cpu.h os_cpu_a.asm
  group ucosii_config
    ./ucosii/config/: includes.h os_cfg.h
  group user
    ./user/: main.c stm32f10x_it.c system_stm32f10x.c stm32f10x_conf.h usart.c
  group core
    ./core/: startup_stm32f10x_hd.s
  group lib
    ./lib/src/: stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c
software components: CMSIS:CORE 5.3.0
