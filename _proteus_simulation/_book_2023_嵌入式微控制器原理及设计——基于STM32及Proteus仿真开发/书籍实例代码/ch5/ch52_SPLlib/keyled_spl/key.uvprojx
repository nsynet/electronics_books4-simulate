# Keil uVision project key.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\lib\inc;.\user
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ./core/: startup_stm32f10x_md.s
  group user
    ./user/: main.c system_stm32f10x.c stm32f10x_it.c led.c key.c
  group lib
    ./lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c
software components: CMSIS:CORE 5.3.0
